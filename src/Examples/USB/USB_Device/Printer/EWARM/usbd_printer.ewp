# IAR project usbd_printer.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xG GD GD32F450xG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F450
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_driver\Include; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_Mouse.srec
  ILINK.IlinkOutputFile: USBD_printer.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F450xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration USBHS(ulpi_phy) (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBHS; USE_ULPI_PHY; GD32F450
  group Application
    ../src/: gd32f4xx_it.c main.c printer_core.c usb_delay.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_Peripherals
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450.s
  group USBD_Drivers
    ../../../../../Firmware/GD32F4xx_usb_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
