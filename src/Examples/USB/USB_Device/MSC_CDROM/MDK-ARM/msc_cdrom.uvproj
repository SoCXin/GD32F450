# Keil uVision project msc_cdrom.uvproj, settings and files
target USBFS_MSC_CDROM (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: MSC_CDROM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F450
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_driver\Include;..\..\..\..\..\Utilities
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: main.c gd32f4xx_it.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_sram_access.c data.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph_Driver
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450.s
  group USB_Driver
    ../../../../../Firmware/GD32F4xx_usb_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../: readme.txt
target USBHS_MSC_CDROM(ulpi_phy) (ARM-ADS)
  device: GD32F450IG GigaDevice
  cpu: as above
  output: MSC_CDROM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBHS,USE_ULPI_PHY,GD32F450
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
