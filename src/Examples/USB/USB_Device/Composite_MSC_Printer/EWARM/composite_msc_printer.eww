<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\composite_msc_printer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


