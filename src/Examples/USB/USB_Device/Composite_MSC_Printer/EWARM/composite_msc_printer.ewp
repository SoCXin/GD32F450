# IAR project composite_msc_printer.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F450
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F4xx_usb_driver\Include; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: composite_hid_cdc.srec
  ILINK.IlinkOutputFile: Project.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32f4xx_it.c msc_printer_wrapper.c printer_core.c usb_delay.c usbd_bbb_scsi.c usbd_msc_core.c usbd_sram_access.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group Doc
    ../: readme.txt
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f450.s
  group USB_Drivers
    ../../../../../Firmware/GD32F4xx_usb_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
